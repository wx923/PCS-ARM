# Keil uVision project project_root.uvprojx, settings and files
target project_root (6210000::V6.21::ARMCLANG)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project_root
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32F30X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Firmware;..\Firmware\CMSIS\Include;..\Firmware\CMSIS;..\Firmware\GD32F30x_standard_peripheral\Include;..\FreeRTOS\FreeRTOS-Kernel\include;..\FreeRTOS\FreeRTOS-Kernel;..\FreeRTOS\FreeRTOS-Kernel\portable\GCC\ARM_CM4F;..\APP;..\Modules\BSP\inc;..\Modules\Service
  asm include: ..\Firmware\CMSIS;..\Firmware\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../Firmware/CMSIS/Include/: gd32f30x_libopt.h
    ../APP/: main.c
    ../FreeRTOS/FreeRTOS-Kernel/: FreeRTOSConfig.h
  group BSP
    ../Modules/BSP/src/: bsp_debugled.c bsp_74hc595.c bsp_24lc128.c
  group Service
    ../Modules/Service/: srv_eeprom.c srv_breatheled.c srv_dsp_status.c
  group FreeRTOS
    ../FreeRTOS/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ../FreeRTOS/FreeRTOS-Kernel/portable/GCC/ARM_CM4F/: port.c
  group Firmware
    ../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ../Firmware/CMSIS/: system_gd32f30x.c startup_gd32f30x_hd.s
